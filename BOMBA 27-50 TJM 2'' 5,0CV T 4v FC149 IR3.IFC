Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: BOMBA 27-50 TJM 2' 5,0CV T 4v FC149 IR3.IFC
Time: 2024-02-15T18:23:52
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: CARCAÇA 63-90 3'' X 2'' - 60380004_TESTE
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: INTERMEDIARIA 27-50 JM FC149 - 60460008 _Interm. 27-50 - 5cv
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Importado1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Importado10
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Importado11
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Importado12
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Importado13
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Importado14
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Importado2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Importado3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Importado4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Importado5
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Importado6
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Importado7
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Importado8
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Importado9
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: PLUG DE ESCORVA LATÃO 3-8'' - 60550166_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Latão
